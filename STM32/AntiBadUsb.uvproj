# Keil uVision project AntiBadUsb.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: AntiBadUsb
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: .\lib\inc;.\lib\src;.\stm32f0;.\user;..\AntiBadUsb
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group startUp
    ./: startup_stm32f030x6.s
  group users
    ./user/: main.c
    ./: led.c usart.c led.h usart.h key.c key.h global.c global.h
  group lib
    ./lib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c
